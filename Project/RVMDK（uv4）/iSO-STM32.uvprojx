# Keil uVision project iSO-STM32.uvprojx, settings and files
target 液晶触摸 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ../../Output/Template.bin ../../Output/obj/Template.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\Lcd;..\..\User\SysTick;..\..\User\touch;..\..\User\spi_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h dwgl_global.c dwgl_function.c dwgl_dac.c dwgl_adc.c dwgl_dma.c dwgl_tim.c dwgl_exti.c dwgl_sci.c dwgl_spi.c dwgl_tft.c AsciiLib_65k.c dwgl_chipflash.c wdg.c HzLib_65k.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/touch/: bsp_gpio_spi.c
    ../../User/led/: bsp_led.c
    ../../User/spi_flash/: PM25LQ512FLASH.c
    ../../User/lcd/: dwgl_WB_LCD.c
    ../../User/icon/: gImage7_128_128_1bitC.c gImage9_128_128_1bitC.c gImage10_16_288_1bitC.c gImage11_240_100_16bitC.c gImage12_128_128_1bitC.c
    E:/Keil_v5/ARM/ARMCC/include/: string.h
software components: CMSIS:CORE 4.3.0
